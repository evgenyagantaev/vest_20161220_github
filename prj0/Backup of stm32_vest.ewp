# IAR project Backup of stm32_vest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205RG ST STM32F205RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_USB_OTG_FS
  ICCARM.CCIncludePath2: Libraries\CMSIS\Device\ST\STM32F2xx\Include; Libraries\CMSIS\Include; Libraries\STM32F2xx_StdPeriph_Driver\inc; ; FreeRTOS\include; FreeRTOS\portable\IAR\ARM_CM3\; Classes; tasks; Libraries\SDIO_Driver\; Libraries\fatfs\src\; Libraries\flash\; Libraries\USBDLib\USBCore\inc\; Libraries\USBDLib\STM32_USB_Device_Library\Core\inc; Libraries\USBDLib\STM32_USB_Device_Library\Class\msc\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  AARM.AUserIncludes: 
  OBJCOPY.OOCOutputFile: stm32_vest.bin
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkIcfFile: stm32f205xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: 5.srec
  group (top)
    Libraries/Flash/: flash_if.c
    ./: FreeRTOSConfig.h main.cpp main.h stm32f2xx_conf.h stm32f2xx_it.c
  group CMSIS
    Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/iar/: startup_stm32f2xx.s
    Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
  group FatFs
    Libraries/fatfs/src/: ff.c
    Libraries/fatfs/src/option/: unicode.c
  group FreeRTOS
    FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
  group FreeRTOS/portable
    FreeRTOS/portable/MemMang/: heap_3.c
    FreeRTOS/portable/IAR/ARM_CM3/: port.c portasm.s
  group SDDriver
    Libraries/SDIO_Driver/: stm32_sdio_common.c stm32_sdio_sd.c
  group StdPeriphLib
    Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group USBDLIB/USBCore/Inc
    Libraries/USBDLib/USBCore/inc/: usb_bsp.h usb_conf.h usb_core.h usb_dcd.h usb_dcd_int.h usb_defines.h usb_regs.h
  group USBDLIB/USBCore/Src
    Libraries/USBDLib/USBCore/src/: usb_bsp.c usb_core.c usb_dcd.c usb_dcd_int.c
  group USBDLIB/USBDevice/Class/MSC/Inc
    Libraries/USBDLib/STM32_USB_Device_Library/Class/msc/inc/: usbd_msc_bot.h usbd_msc_core.h usbd_msc_data.h usbd_msc_mem.h usbd_msc_scsi.h
  group USBDLIB/USBDevice/Class/MSC/Src
    Libraries/USBDLib/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c usbd_storage_msd.c
  group USBDLIB/USBDevice/Core/Inc
    Libraries/USBDLib/STM32_USB_Device_Library/Core/inc/: usbd_conf.h usbd_core.h usbd_def.h usbd_desc.h usbd_ioreq.h usbd_req.h usbd_usr.h
  group USBDLIB/USBDevice/Core/Src
    Libraries/USBDLib/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_desc.c usbd_ioreq.c usbd_req.c usbd_usr.c
